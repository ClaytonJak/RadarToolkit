options:
  parameters:
    generate_options: qt_gui
    id: digital_mod_analysis
    output_language: python
    title: FM Practice
  states: {}

blocks:
- name: BW_sig
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: f_c
  id: variable
  parameters:
    value: '100000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 250e6
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*BW_sig)
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: BW_sig
    fh: '-1.0'
    max_dev: BW_sig
    quad_rate: f_c
    tau: '75e-6'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: f_c
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', qtgui_sink_x_0_0, '0']
- [analog_sig_source_x_1, '0', analog_wfm_tx_0, '0']
- [analog_wfm_tx_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_wfm_tx_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
