options:
  parameters:
    generate_options: qt_gui
    id: options_0
    output_language: python
    title: radar_test
  states: {}

blocks:
- name: BW_sig
  id: variable
  parameters:
    value: '25000'
  states: {}
- name: f_c
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: norm_amp
  id: variable
  parameters:
    value: 1/.707
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: norm_amp
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: analog_fastnoise_source_x_0_0
  id: analog_fastnoise_source_x
  parameters:
    amp: norm_amp
    noise_type: analog.GR_GAUSSIAN
    samples: '4212'
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(0.5*samp_rate)
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '0.05'
    type: complex
  states: {}
- name: blocks_multiply_const_xx_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: '0.5'
    type: complex
  states: {}
- name: blocks_multiply_const_xx_0_1
  id: blocks_multiply_const_xx
  parameters:
    const: '0.05'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: f_c
    fftsize: '1024'
    label1: Radar Tx
    label2: Radar Rx
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: f_c
    fftsize: '1024'
    type: complex
  states: {}
- name: radar_signal_generator_fmcw_c_0
  id: radar_signal_generator_fmcw_c
  parameters:
    amplitude: norm_amp
    freq_cw: f_c
    freq_sweep: BW_sig
    len_key: '"packet_len"'
    samp_cw: '0'
    samp_down: int(samp_rate*10)
    samp_rate: int(samp_rate)
    samp_up: int(samp_rate*100)
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_multiply_const_xx_0, '0']
- [analog_fastnoise_source_x_0_0, '0', blocks_multiply_const_xx_0_1, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_add_xx_0_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_delay_0, '0', blocks_multiply_const_xx_0_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_xx_0_0, '0', blocks_add_xx_0_0, '1']
- [blocks_multiply_const_xx_0_1, '0', blocks_add_xx_0_0, '0']
- [radar_signal_generator_fmcw_c_0, '0', blocks_add_xx_0, '0']
- [radar_signal_generator_fmcw_c_0, '0', blocks_multiply_const_xx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
