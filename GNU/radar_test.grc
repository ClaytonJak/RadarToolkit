options:
  parameters:
    generate_options: qt_gui
    id: options_0
    output_language: python
    title: radar_test
  states: {}

blocks:
- name: BW_sig
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: f_c
  id: variable
  parameters:
    value: '100000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 250e6
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '0.05'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: f_c
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: f_c
    fftsize: '1024'
    type: complex
  states: {}
- name: radar_signal_generator_cw_c_0
  id: radar_signal_generator_cw_c
  parameters:
    amplitude: '1'
    frequency: samp_rate/f_c
    len_key: '"packet_len"'
    packet_len: '100'
    samp_rate: int(samp_rate)
  states: {}
- name: radar_signal_generator_sync_pulse_c_0
  id: radar_signal_generator_sync_pulse_c
  parameters:
    len_key: '"packet_len"'
    packet_len: '1'
    pulse_amplitude: '1'
    pulse_len: '6000'
    pulse_pause: '6000'
  states: {state: disabled}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [radar_signal_generator_cw_c_0, '0', blocks_add_xx_0, '0']
- [radar_signal_generator_cw_c_0, '0', blocks_multiply_xx_0, '1']
- [radar_signal_generator_sync_pulse_c_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
